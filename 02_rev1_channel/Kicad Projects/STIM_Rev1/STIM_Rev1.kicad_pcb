# Repository WeymenKoo/STIM-Rev1-Hardware (continued)

## KiCad design 02_rev1_channel/Kicad Projects/STIM_Rev1/STIM_Rev1.kicad_pcb (continued)

Schematic: output-limiter-photomos.kicad_sch, Output - Limiter & PhotoMOS

Parts:
C21: 47p C0G 50V 0603; C_0603_1608Metric; MPN CL10C470JB8NNNC; LCSC C1671
D5: SMBJ100CA; D_SMB; MPN SMBJ100CA-13-F; LCSC C135029
D6: OUT EN red 0805; LED_0805_2012Metric; MPN NCD0805R1; LCSC C84256
J4: ELECTRODES 2P 5.08mm; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; MPN KF128-5.08-2P-AA; LCSC C474952
JP4, JP5, JP6: JP 1x2; PinHeader_1x02_P2.54mm_Vertical
M1, M2: DN2540N8; SOT-89-3; MPN DN2540N8-G; LCSC C145573; not fitted
Q20: 2N7002; SOT-23; MPN 2N7002; LCSC C8545
R20A1, R20B1: 10.0M 1% 200V 1206; R_1206_3216Metric; MPN FRC1206F1005TS; LCSC C2933576
R21: 200k 1% 200V 1206; R_1206_3216Metric; MPN 1206W4F2003T5E; LCSC C17954
R22: 100k 1% 0603; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
RLED1: 750 1% 1206; R_1206_3216Metric; MPN 1206W4F7500T5E; LCSC C17985
RLIM1: SOT 165-432 1% 0805; R_0805_2012Metric; MPN E96 kit 165-432 Ohm 0805 1 %; not fitted
RSHR1: 10 0.1% 25ppm 0603; R_0603_1608Metric; MPN RT0603BRD0710RL; LCSC C861082
TP14: ENABLE; TestPoint_Keystone_5000-5004_Miniature
TP22: LIM_OUT; TestPoint_Keystone_5000-5004_Miniature
TP23: ELECTRODE_STIM; TestPoint_Keystone_5000-5004_Miniature
TP24: ELECTRODE_RET; TestPoint_Keystone_5000-5004_Miniature
TP25: RET_SHUNT; TestPoint_Keystone_5000-5004_Miniature
TP26: PMOS_LED_K; TestPoint_Keystone_5000-5004_Miniature
U4, U5: AQY214S; Panasonic_SOP-4_4.4x4.3mm_P2.54mm; MPN AQY214SX; LCSC C719755

Connections:
+12V: D6.2 (A); also elsewhere on the board
/ENABLE: Q20.1 (G), R22.1, TP14.1 (1_1); also elsewhere on the board
/VMID: C21.2, R21.2; also elsewhere on the board
/[7] Analog - Howland Current Pump/I_SENSE: JP4.1 (A), M1.2 (D); also elsewhere on the board
/[8] Output - Limiter & PhotoMOS/ELECTRODE_RET: J4.2, JP6.2 (B), TP24.1 (1_1), U5.4 (OUT2)
/[8] Output - Limiter & PhotoMOS/ELECTRODE_STIM: D5.1 (A1), J4.1, JP5.2 (B), R20A1.1, TP23.1 (1_1), U4.4 (OUT2); also elsewhere on the board
/[8] Output - Limiter & PhotoMOS/LIM_OUT: JP4.2 (B), JP5.1 (A), M2.2 (D), TP22.1 (1_1), U4.3 (OUT1)
/[8] Output - Limiter & PhotoMOS/LIM_SRC_A: M1.3 (S), M2.1 (G), RLIM1.1
/[8] Output - Limiter & PhotoMOS/LIM_SRC_B: M1.1 (G), M2.3 (S), RLIM1.2
/[8] Output - Limiter & PhotoMOS/PMOS_LED_A: RLED1.2, U4.1 (LED_A)
/[8] Output - Limiter & PhotoMOS/PMOS_LED_K: Q20.3 (D), TP26.1 (1_1), U5.2 (LED_K)
/[8] Output - Limiter & PhotoMOS/RET_SHUNT: JP6.1 (A), RSHR1.1, TP25.1 (1_1), U5.3 (OUT1); also elsewhere on the board
/[8] Output - Limiter & PhotoMOS/VDIV_MID: R20A1.2, R20B1.1
/[8] Output - Limiter & PhotoMOS/V_ELEC_DIV: C21.1, R20B1.2, R21.1; also elsewhere on the board
unnamed: D6.1 (K), RLED1.1
unnamed: U4.2 (LED_K), U5.1 (LED_A)

Notes on the sheet:
[8] Output - Limiter & PhotoMOS
PhotoMOS Switches, TVS, Electrodes and Return Shunt
DN2540 Current Limiter
MISC NOTE M1: Buy ~10 DN2540N8 per channel; pair them within 100 mV of Vgs at 7.6 mA. RLIM1 is 0805 for hand rework.
DESIGN NOTE D4: D5 SMBJ100CA: VRWM 100 V, VBR 111 V min, above the 110 V rail.
DESIGN NOTE D1: Limiter (D-02): matched DN2540 pair, one shared RLIM selected on test for 7.6 mA: R = (|Vgs at 7.6 mA| + 10 mV) / 7.6 mA, nearest E96. Limit 6.4-8.8 mA over spread and 0-50 C.
DESIGN NOTE D2: U4 (stimulating) and U5 (return) share one LED string: one failure opens both. D6 OUT EN is in the string and lights only while the electrodes are live; RLED1 750 Ohm sets ~10 mA.
DESIGN NOTE D3: ENABLE low or open (R22 pull-down) = LED string off = both switches open.
LAYOUT NOTE L1: Divider: R20A1 in the HV island, R20B1 straddles the gap (V_ELEC_DIV pad on the LV side), R21/C21 on the LV side next to it.
LAYOUT NOTE L2: RSHR: Kelvin traces from its pads to U22 (0.1 % part, D5); keep the return path J4 -> U5 -> RSHR -> GND short.
LAYOUT NOTE L3: PhotoMOS straddle the gap: LED pins (1, 2) toward the LV zone, switch pins (3, 4) toward HV.

Schematic: sense-feedback-adc.kicad_sch, Sense - Feedback to ADC

Parts:
C94, C95: 100n X7R 50V 0603; C_0603_1608Metric; MPN CL10B104KB8NNNC; LCSC C1591
R50: 5.1k 1% 0603; R_0603_1608Metric; MPN 0603WAF5101T5E; LCSC C23186
R51: 14.7k 1% 0603; R_0603_1608Metric; MPN 0603WAF1472T5E; LCSC C22874
R52: 10.0k 1% 0603; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804
R53, R54, R55: 1k 1% 0603; R_0603_1608Metric; MPN 0603WAF1001T5E; LCSC C21190
R70: 1.00k 0.1% 25ppm 0805; R_0805_2012Metric; MPN RT0805BRD071KL; LCSC C110774
R71: 19.1k 0.1% 25ppm 0603; R_0603_1608Metric; MPN RT0603BRD0719K1L; LCSC C861184
R72, R73, R74, R75: 10.0k 0.1% 25ppm 0603; R_0603_1608Metric; MPN RT0603BRD0710KL; LCSC C95204
TP27: I_RETURN_ADC; TestPoint_Keystone_5000-5004_Miniature
TP28: V_ELEC_ADC; TestPoint_Keystone_5000-5004_Miniature
TP29: VMID_REF; TestPoint_Keystone_5000-5004_Miniature
U22: OPA4192; TSSOP-14_4.4x5mm_P0.65mm; MPN OPA4192IPWR; LCSC C2057935
U29: LM4040A41 4.096V 0.1%; SOT-23; MPN LM4040AIM3-4.1/NOPB; LCSC C126807

Connections:
+9V: R50.1; also elsewhere on the board
+12V: C94.1, U22.4 (V+); also elsewhere on the board
-12V: C95.1, U22.11 (V-); also elsewhere on the board
/I_RETURN_ADC: R54.2, TP27.1 (1_1); also elsewhere on the board
/VMID: R53.1, R73.2, U22.13 (-), U22.14; also elsewhere on the board
/VMID_REF: R53.2, TP29.1 (1_1); also elsewhere on the board
/V_ELEC_ADC: R55.2, TP28.1 (1_1); also elsewhere on the board
/[8] Output - Limiter & PhotoMOS/RET_SHUNT: U22.3 (+); also elsewhere on the board
/[8] Output - Limiter & PhotoMOS/V_ELEC_DIV: U22.10 (+); also elsewhere on the board
/[9] Sense - Feedback to ADC/IRET_FB: R70.1, R71.1, U22.2 (-)
/[9] Sense - Feedback to ADC/IRET_SUM_N: R74.2, R75.1, U22.6 (-)
/[9] Sense - Feedback to ADC/IRET_SUM_P: R72.2, R73.1, U22.5 (+)
/[9] Sense - Feedback to ADC/I_RETURN_BUF: R54.1, R75.2, U22.7
/[9] Sense - Feedback to ADC/I_RETURN_X20: R71.2, R72.1, U22.1
/[9] Sense - Feedback to ADC/VMID_DIV: R51.2, R52.1, U22.12 (+)
/[9] Sense - Feedback to ADC/VREF_4V096: R50.2, R51.1, U29.1 (K)
/[9] Sense - Feedback to ADC/V_ELEC_BUF: R55.1, U22.8, U22.9 (-)

Notes on the sheet:
Read-back Amplifiers: Return Current x20 + VMID, Electrode Voltage Buffer
VMID Reference
MISC NOTE M1: R53-R55 1 k isolate the cable capacitance from U22; the FPGA subtracts VMID_REF from both read-backs.
DESIGN NOTE D3: VMID = 4.096 V x 10.0k / 24.7k = 1.658 V (half of a 3.3 V ADC). Other ADC range: re-select R51/R52. U29 runs at ~0.8 mA from +9 V.
LAYOUT NOTE L2: C94/C95 at U22 pins 4 and 11, via at the pad.
DESIGN NOTE D1: I_RETURN_ADC = VMID + 0.201 V/mA: RSHR 10 mV/mA x 20.1 (U22A, R71/R70) + VMID (U22B, R72-R75 0.1 %). +/-5 mA -> 0.66-2.66 V.
DESIGN NOTE D2: V_ELEC_ADC = VMID + V_elec / 101 (20 MOhm / 200 k returned to VMID); U22C buffers it (20 pA bias).
LAYOUT NOTE L1: 0.1 % set R72-R75: short, symmetric traces; no copper pour between their pads.
[9] Sense - Feedback to ADC

Schematic: interface-adc-readback.kicad_sch, Interface - ADC Read-back

Notes on the sheet:
DESIGN NOTE D1: Ports only: no parts yet. Serial ADC on the isolated side reading the [9] outputs: I_RETURN_ADC = VMID + 0.2 V/mA and V_ELEC_ADC = VMID + V_elec/101, both sized for a 0-3.3 V input; VMID_REF (1.66 V) is available as the mid-scale reference. Channel count, resolution, sample rate, CO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
[12] Interface - ADC Read-back

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
Board: 4 copper layers, 127 parts (0 on the bottom side), 60 nets, no tracks yet.

Other parts of the board:
D1B1, D2B1: BAS16; SOT-23
JP3: JP 1x2; PinHeader_1x02_P2.54mm_Vertical
QD1: MMBTA92; SOT-23
QD2: MMBTA42; SOT-23
TP1: +HV_IN; TestPoint_Keystone_5000-5004_Miniature
TP3: -HV_IN; TestPoint_Keystone_5000-5004_Miniature

Their connections:
+HV: QD2.3 (C); also elsewhere on the board
+HV_IN: TP1.1 (1_1); also elsewhere on the board
-HV: QD1.3 (C); also elsewhere on the board
-HV_IN: TP3.1 (1_1); also elsewhere on the board
/[7] Analog - Howland Current Pump/PUMP_OUT: D1B1.3 (K); also elsewhere on the board
/[7] Analog - Howland Current Pump/Q1_BASE: QD1.2 (E); also elsewhere on the board
/[7] Analog - Howland Current Pump/Q2_BASE: QD2.2 (E); also elsewhere on the board
/[8] Output - Limiter & PhotoMOS/ELECTRODE_STIM: JP3.2 (B); also elsewhere on the board
